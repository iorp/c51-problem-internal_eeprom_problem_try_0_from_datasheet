# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: IS89C52 ISSI
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(40000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Keil\C51\H
  group Source Group 1
    ./: STARTUP.A51 main.c uart.c uart.h
    ./header/: stc12.h
